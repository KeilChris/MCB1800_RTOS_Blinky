# Keil uVision project Blinky.uvprojx, settings and files
target ULINKpro (6170000::V6.17::.\ARMCLANG6.17)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Sources
    ./: Blinky.c main.c main.h
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.0, Board Support:A/D Converter 1.0.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.1.0, Device:SCU 1.1.0, Device:Startup 1.0.0
